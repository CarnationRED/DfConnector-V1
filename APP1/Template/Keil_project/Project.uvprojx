# Keil uVision project Project.uvprojx, settings and files
target GD32C10X (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32C103RB GigaDevice
  pack: GigaDevice.GD32C10x_DFP.1.0.1
  cpu: IRAM(0x20000000,0x08000) IROM(0x08000000,0x020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32C10X,GD32C103V_EVAL
  c include: ..\..\Firmware\CMSIS;..\..\Utilities;..\;..\..\Firmware\CMSIS\GD\GD32C10x\Include;..\..\Firmware\GD32C10x_standard_peripheral\Include;..\..\Template;..\..\Firmware\GD32C10x_usbfs_library\device\class\hid\Include;..\..\Firmware\GD32C10x_usbfs_library\ustd\class\hid;..\..\Firmware\GD32C10x_usbfs_library\driver\Include;..\..\Firmware\GD32C10x_usbfs_library\device\core\Include;..\USB;..\..\Firmware\GD32C10x_usbfs_library\ustd\common\
  library: MicroLIB
  memory RVCT4: ROM 0x8001000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../: main.c gd32c10x_it.c WIFI.c delay.c M8266WIFIDrv.c M8266WIFIDrv_STM32F2xx.a Messages.c VCI.c VCI.h buzzer.h buzzer.c
  group CMSIS
    ../../Firmware/CMSIS/GD/GD32C10x/Source/: system_gd32c10x.c
  group Peripherals
    ../../Firmware/GD32C10x_standard_peripheral/Source/: gd32c10x_adc.c gd32c10x_bkp.c gd32c10x_can.c gd32c10x_crc.c gd32c10x_ctc.c gd32c10x_dac.c gd32c10x_dbg.c gd32c10x_dma.c gd32c10x_exmc.c gd32c10x_exti.c gd32c10x_fmc.c gd32c10x_fwdgt.c gd32c10x_gpio.c gd32c10x_i2c.c gd32c10x_misc.c gd32c10x_pmu.c gd32c10x_rcu.c gd32c10x_rtc.c gd32c10x_spi.c gd32c10x_timer.c gd32c10x_usart.c gd32c10x_wwdgt.c
  group Startup
    ../../Firmware/CMSIS/GD/GD32C10x/Source/ARM/: startup_gd32c10x.s
  group Utilities
    ../../Utilities/: gd32c10x_eval.c
