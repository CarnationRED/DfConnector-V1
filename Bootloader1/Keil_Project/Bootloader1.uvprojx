# Keil uVision project Bootloader1.uvprojx, settings and files
target Bootloader1 (6160000::V6.16::ARMCLANG)
  device: GD32C103RB GigaDevice
  pack: GigaDevice.GD32C10x_DFP.1.0.1
  cpu: IRAM(0x20000000,0x08000) IROM(0x08000000,0x020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Bootloader1
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32C10X,GD32C103V_EVAL
  c include: ..\Utilities;..\..\Bootloader1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group Main
    ../: main.c delay.c gd32c10x_it.c
  group Header
    ../: delay.h gd32c10x_it.h main.h
software components: CMSIS:CORE 5.5.0, Device:GD32C10x_StdPeripherals:ADC 1.0.0, Device:GD32C10x_StdPeripherals:BKP 1.0.0, Device:GD32C10x_StdPeripherals:CAN 1.0.0, Device:GD32C10x_StdPeripherals:CRC 1.0.0, Device:GD32C10x_StdPeripherals:CTC 1.0.0, Device:GD32C10x_StdPeripherals:DAC 1.0.0, Device:GD32C10x_StdPeripherals:DBG 1.0.0, Device:GD32C10x_StdPeripherals:DMA 1.0.0, Device:GD32C10x_StdPeripherals:EXMC 1.0.0, Device:GD32C10x_StdPeripherals:EXTI 1.0.0, Device:GD32C10x_StdPeripherals:FMC 1.0.0, Device:GD32C10x_StdPeripherals:FWDGT 1.0.0, Device:GD32C10x_StdPeripherals:GPIO 1.0.0, Device:GD32C10x_StdPeripherals:I2C 1.0.0, Device:GD32C10x_StdPeripherals:MISC 1.0.0, Device:GD32C10x_StdPeripherals:PMU 1.0.0, Device:GD32C10x_StdPeripherals:RCU 1.0.0, Device:GD32C10x_StdPeripherals:RTC 1.0.0, Device:GD32C10x_StdPeripherals:SPI_I2S 1.0.0, Device:GD32C10x_StdPeripherals:TIMER 1.0.0, Device:GD32C10x_StdPeripherals:USART 1.0.0, Device:GD32C10x_StdPeripherals:WWDGT 1.0.0, Device:GD32C10x_libopt 1.0.0, Device:Startup 1.0.0
